RDEPENDS:packagegroup-qcom-ml:append = "  \
      qnn \
      snpe \
    "
