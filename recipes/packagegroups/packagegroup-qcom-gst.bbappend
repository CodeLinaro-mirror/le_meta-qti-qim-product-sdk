RDEPENDS:packagegroup-qcom-gst:append = "  \
        gstreamer1.0-plugins-qcom-oss-mlsnpe \
        gstreamer1.0-plugins-qcom-oss-mlqnn \
  "
